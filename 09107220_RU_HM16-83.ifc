Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: dc34158d-2fb6-4d5e-a078-69e2772f9afd, NumberOfSaves: 1]
File name: 0001
Time: 2024-08-15T10:28:57+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 09107220_RU_HM16-83:53168301_RU_9107220_HM16-83, (2)
In: Default
Type - Material: z_Miele_Design_BRWS, z_Miele_Design_CLST, <Unnamed>, z_Miele_Connection_Connection_Modul, Roller
Type - Pset_ProductRequirements - Category: Specialty Equipment
Classification: E1010620 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 53168301_RU_9107220_HM16-83; sets with these values: 2
